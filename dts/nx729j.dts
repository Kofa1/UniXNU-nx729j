Yªçx-®éÜj×¢ëiºÚ+§j[héÜ¢éíãùÛü×{o+^²¢¶×/dts-v1/;

/ {
	model = "Qualcomm Technologies, Inc. Kalama MTP";
	compatible = "qcom,kalama-mtp\0qcom,kalama\0qcom,mtp";
	qcom,msm-id = <0x207 0x20000 0x207 0x10000 0x218 0x20000 0x218 0x10000>;
	interrupt-parent = <0x01>;
	#address-cells = <0x02>;
	#size-cells = <0x02>;
	qcom,board-id = <0x10008 0x00>;

	memory {
		ddr_device_type = <0x08>;
		device_type = "memory";
		reg = <0x08 0xc0000000 0x01 0x40000000>;
	};

	ddr-regions {
		region2 = <0x0a 0x00 0x02 0x00 0x00 0x00 0x00 0x08 0x00 0x400>;
		region1 = <0x08 0x80000000 0x01 0x80000000 0x00 0x00 0x00 0x02 0x00 0x400>;
		region0 = <0x00 0x80000000 0x00 0x80000000 0x00 0x00 0x00 0x00 0x00 0x400>;
	};

	chosen {
		linux,initrd-end = <0x00 0xb7ffe7bc>;
		linux,initrd-start = <0x00 0xb6ea0000>;
		kaslr-seed = <0x00 0x00>;
		bootargs = "console=ttyMSM0,115200n8 loglevel=6 kpti=0 log_buf_len=256K kernel.panic_on_rcu_stall=1 service_locator.enable=1 msm_rtb.filter=0x237 rcupdate.rcu_expedited=1 rcu_nocbs=0-7 ftrace_dump_on_oops swiotlb=noforce loop.max_part=7 fw_devlink.strict=1 allow_mismatched_32bit_el0 cpufreq.default_governor=performance printk.console_no_auto_verbose=1 kasan=off sysctl.kernel.sched_pelt_multiplier=4 can.stats_timer=0 pcie_ports=compat irqaffinity=0-2 disable_dma32=on no-steal-acc cgroup.memory=nokmem,nosocket video=vfb:640x400,bpp=32,memsize=3072000 nosoftlockup bootconfig  msm_drm.dsi_display0=qcom,mdss_dsi_bf068_rm692h0_6p97_magic_dsc_cmd: rootwait ro init=/init mem=12592218112B memhp_default_state=online movable_node";
		phandle = <0x2d2>;
	};

	/* The source DTB nests PSCI under /soc; ADT requires this root-level handoff. */
	psci {
		compatible = "arm,psci-1.0";
		method = "smc";
	};

	reserved-memory {
		#address-cells = <0x02>;
		#size-cells = <0x02>;
		ranges;
		phandle = <0x2d3>;

		gunyah_hyp_region@80000000 {
			no-map;
			reg = <0x00 0x80000000 0x00 0xa00000>;
			phandle = <0x2d4>;
		};

		cpusys_vm_region@80a00000 {
			no-map;
			reg = <0x00 0x80a00000 0x00 0x400000>;
			phandle = <0x86>;
		};

		xbl_dt_log_merged@81a00000 {
			no-map;
			reg = <0x00 0x81a00000 0x00 0x260000>;
			phandle = <0x2d5>;
		};

		aop_cmd_db_region@81c60000 {
			compatible = "qcom,cmd-db";
			no-map;
			reg = <0x00 0x81c60000 0x00 0x20000>;
			phandle = <0x2d6>;
		};

		aop_config_merged_region@81c80000 {
			no-map;
			reg = <0x00 0x81c80000 0x00 0x74000>;
			phandle = <0x2d7>;
		};

		smem_region@81d00000 {
			no-map;
			reg = <0x00 0x81d00000 0x00 0x200000>;
			phandle = <0x68>;
		};

		adsp_mhi_region@81f00000 {
			no-map;
			reg = <0x00 0x81f00000 0x00 0x20000>;
			phandle = <0x2d8>;
		};

		global_sync_region@82600000 {
			no-map;
			reg = <0x00 0x82600000 0x00 0x100000>;
			phandle = <0x2d9>;
		};

		tz_stat_region@82700000 {
			no-map;
			reg = <0x00 0x82700000 0x00 0x100000>;
			phandle = <0x2da>;
		};

		mpss_region@89800000 {
			no-map;
			reg = <0x00 0x8a800000 0x00 0x10800000>;
			phandle = <0x7f>;
		};

		q6_mpss_dtb_region@9b000000 {
			no-map;
			reg = <0x00 0x9b000000 0x00 0x80000>;
			phandle = <0x80>;
		};

		ipa_fw_region@9b080000 {
			no-map;
			reg = <0x00 0x9b080000 0x00 0x10000>;
			phandle = <0x2db>;
		};

		ipa_gsi_region@9b090000 {
			no-map;
			reg = <0x00 0x9b090000 0x00 0xa000>;
			phandle = <0x2dc>;
		};

		gpu_micro_code_region@9b09a000 {
			no-map;
			reg = <0x00 0x9b09a000 0x00 0x2000>;
			phandle = <0x2dd>;
		};

		spss_region_region@9b100000 {
			no-map;
			reg = <0x00 0x9b100000 0x00 0x180000>;
			phandle = <0x3f>;
		};

		spu_tz_shared_mem@9b280000 {
			no-map;
			reg = <0x00 0x9b280000 0x00 0x60000>;
			phandle = <0x1f6>;
		};

		spu_modem_shared_mem@9b2e0000 {
			no-map;
			reg = <0x00 0x9b2e0000 0x00 0x20000>;
			phandle = <0x1f5>;
		};

		camera_region@9b300000 {
			no-map;
			reg = <0x00 0x9b300000 0x00 0x800000>;
			phandle = <0x2de>;
		};

		video_region@9bb00000 {
			no-map;
			reg = <0x00 0x9bb00000 0x00 0x700000>;
			phandle = <0x2df>;
		};

		cvp_region@9c200000 {
			no-map;
			reg = <0x00 0x9c200000 0x00 0x700000>;
			phandle = <0x2bc>;
		};

		cdsp_region@9c900000 {
			no-map;
			reg = <0x00 0x9c900000 0x00 0x2000000>;
			phandle = <0x79>;
		};

		q6_cdsp_dtb_region@9e900000 {
			no-map;
			reg = <0x00 0x9e900000 0x00 0x80000>;
			phandle = <0x7a>;
		};

		q6_adsp_dtb_region@9e980000 {
			no-map;
			reg = <0x00 0x9e980000 0x00 0x80000>;
			phandle = <0x75>;
		};

		adspslpi_region@9ea00000 {
			no-map;
			reg = <0x00 0x9ea00000 0x00 0x4080000>;
			phandle = <0x74>;
		};

		ramoops@c0000000 {
			no-map;
			reg = <0x00 0xc0000000 0x00 0x200000>;
			phandle = <0x3e>;
		};

		mpss_dsm_region@d4d00000 {
			no-map;
			reg = <0x00 0xd4d00000 0x00 0x3300000>;
			phandle = <0x82>;
		};

		tz_reserved_region@d8000000 {
			no-map;
			reg = <0x00 0xd8000000 0x00 0x100000>;
			phandle = <0x2e0>;
		};

		xbl_sc_region@d8100000 {
			no-map;
			reg = <0x00 0xd8100000 0x00 0x40000>;
			phandle = <0x2e1>;
		};

		cpucp_fw_region@d8140000 {
			no-map;
			reg = <0x00 0xd8140000 0x00 0x1c0000>;
			phandle = <0x2e2>;
		};

		qtee_region@d8300000 {
			no-map;
			reg = <0x00 0xd8300000 0x00 0x500000>;
			phandle = <0x2e3>;
		};

		hwfence-shmem {
			no-map;
			reg = <0x00 0xe6440000 0x00 0x2dd000>;
			phandle = <0x2e4>;
		};

		trust_ui_vm_region@f3800000 {
			no-map;
			reg = <0x00 0xf3800000 0x00 0x40ee000>;
			phandle = <0x85>;
		};

		trust_ui_vm_dump@0xf78ee000 {
			no-map;
			reg = <0x00 0xf78ee000 0x00 0x1000>;
			phandle = <0x30>;
		};

		trust_ui_vm_qrtr@0xf78ef000 {
			no-map;
			reg = <0x00 0xf78ef000 0x00 0x9000>;
			phandle = <0x6e>;
		};

		trust_ui_vm_vblk0_ring@0xf78f8000 {
			no-map;
			reg = <0x00 0xf78f8000 0x00 0x4000>;
			gunyah-label = <0x11>;
			phandle = <0x89>;
		};

		trust_ui_vm_vblk1_ring@0xf78fc000 {
			no-map;
			reg = <0x00 0xf78fc000 0x00 0x4000>;
			gunyah-label = <0x10>;
			phandle = <0x8a>;
		};

		trust_ui_vm_swiotlb@0xf7900000 {
			no-map;
			reg = <0x00 0xf7900000 0x00 0x100000>;
			gunyah-label = <0x12>;
			phandle = <0x8b>;
		};

		oem_vm_vblk0_ring@f7afc000 {
			no-map;
			reg = <0x00 0xf7afc000 0x00 0x4000>;
			gunyah-label = <0x13>;
			phandle = <0x8c>;
		};

		oem_vm_swiotlb@f7b00000 {
			no-map;
			reg = <0x00 0xf7b00000 0x00 0x100000>;
			gunyah-label = <0x14>;
			phandle = <0x8d>;
		};

		oem_vm_region@f7c00000 {
			compatible = "shared-dma-pool";
			reg = <0x00 0xf7c00000 0x00 0x4800000>;
			reusable;
			alignment = <0x00 0x400000>;
			phandle = <0x87>;
		};

		llcc_lpi_region@ff800000 {
			no-map;
			reg = <0x00 0xff800000 0x00 0x600000>;
			phandle = <0x2e5>;
		};

		va_md_mem_region {
			compatible = "shared-dma-pool";
			alloc-ranges = <0x00 0x00 0x00 0xffffffff>;
			reusable;
			size = <0x00 0x1000000>;
			phandle = <0x43>;
		};

		sp_region {
			compatible = "shared-dma-pool";
			alloc-ranges = <0x00 0x00 0x00 0xffffffff>;
			reusable;
			alignment = <0x00 0x400000>;
			size = <0x00 0x1000000>;
			phandle = <0x1f4>;
		};

		cdsp_eva_region {
			compatible = "shared-dma-pool";
			alloc-ranges = <0x00 0x00 0x00 0xffffffff>;
			reusable;
			alignment = <0x00 0x400000>;
			size = <0x00 0x400000>;
			phandle = <0x2bd>;
		};

		adsp_heap_region {
			compatible = "shared-dma-pool";
			alloc-ranges = <0x00 0x00 0x00 0xffffffff>;
			reusable;
			alignment = <0x00 0x400000>;
			size = <0x00 0xc00000>;
			phandle = <0x70>;
		};

		user_contig_region {
			compatible = "shared-dma-pool";
			alloc-ranges = <0x00 0x00 0x00 0xffffffff>;
			reusable;
			alignment = <0x00 0x400000>;
			size = <0x00 0x1000000>;
			phandle = <0x3a>;
		};

		qseecom_region {
			compatible = "shared-dma-pool";
			alloc-ranges = <0x00 0x00 0x00 0xffffffff>;
			reusable;
			alignment = <0x00 0x400000>;
			size = <0x00 0x2400000>;
			phandle = <0x38>;
		};

		secure_cdsp_region {
			compatible = "shared-dma-pool";
			alloc-ranges = <0x00 0x00 0x00 0xffffffff>;
			reusable;
			alignment = <0x00 0x400000>;
			size = <0x00 0x4800000>;
			phandle = <0x1f3>;
		};

		non_secure_display_region {
			compatible = "shared-dma-pool";
			reusable;
			alloc-ranges = <0x00 0x00 0x00 0xffffffff>;
			size = <0x00 0xa400000>;
			alignment = <0x00 0x400000>;
			phandle = <0x1f1>;
		};

		demura_heap_region {
			compatible = "shared-dma-pool";
			reusable;
			alloc-ranges = <0x01 0x00 0xfffffffe 0xffffffff>;
			size = <0x00 0x2800000>;
			alignment = <0x00 0x400000>;
			phandle = <0x1f2>;
		};

		qseecom_ta_region {
			compatible = "shared-dma-pool";
			alloc-ranges = <0x00 0x00 0x00 0xffffffff>;
			reusable;
			alignment = <0x00 0x400000>;
			size = <0x00 0x2400000>;
			phandle = <0x39>;
		};

		glink_contig_region {
			compatible = "shared-dma-pool";
			alloc-ranges = <0x00 0x00 0x00 0xffffffff>;
			reusable;
			alignment = <0x00 0x400000>;
			size = <0x00 0x1000000>;
			phandle = <0x2e6>;
		};

		audio_cma_region {
			compatible = "shared-dma-pool";
			alloc-ranges = <0x00 0x00 0x00 0xffffffff>;
			reusable;
			alignment = <0x00 0x400000>;
			size = <0x00 0x1c00000>;
			phandle = <0x1f7>;
		};

		sdsp_region {
			compatible = "shared-dma-pool";
			alloc-ranges = <0x00 0x00 0x00 0xffffffff>;
			reusable;
			alignment = <0x00 0x400000>;
			size = <0x00 0x800000>;
			phandle = <0x1f8>;
		};

		linux,cma {
			compatible = "shared-dma-pool";
			alloc-ranges = <0x00 0x00 0x00 0xffffffff>;
			reusable;
			alignment = <0x00 0x400000>;
			size = <0x00 0x2000000>;
			linux,cma-default;
			phandle = <0x81>;
		};

		debug_kinfo_region {
			alloc-ranges = <0x00 0x00 0xffffffff 0xffffffff>;
			size = <0x00 0x1000>;
			no-map;
			phandle = <0xe9>;
		};

		mem_dump_region {
			compatible = "shared-dma-pool";
			alloc-ranges = <0x01 0x00 0xfffffffe 0xffffffff>;
			reusable;
			alignment = <0x00 0x400000>;
			size = <0x00 0x3400000>;
			phandle = <0x1f0>;
		};

		cnss_wlan_region {
			phandle = <0x4d0>;
			size = <0x00 0x2000000>;
			alignment = <0x00 0x400000>;
			reusable;
			alloc-ranges = <0x00 0x00 0x00 0xffffffff>;
			compatible = "shared-dma-pool";
		};

		splash_region {
			phandle = <0x6ba>;
			label = "cont_splash_region";
			reg = <0x00 0xb8000000 0x00 0x2b00000>;
		};

		demura_region_0 {
			phandle = <0x6bb>;
			label = "demura hfc region 0";
			reg = <0x00 0x00 0x00 0x00>;
		};

		demura_region_1 {
			phandle = <0x6bc>;
			label = "demura hfc region 1";
			reg = <0x00 0x00 0x00 0x00>;
		};
	};

	mem-offline {
		compatible = "qcom,mem-offline";
		offline-sizes = <0x02 0xc0000000 0x01 0x00>;
		granule = <0x400>;
		mboxes = <0x02 0x00>;
	};

	aliases {
		swr3 = "/soc/spf_core_platform/lpass-cdc/wsa2-macro@6AA0000/wsa2_swr_master";
		swr2 = "/soc/spf_core_platform/lpass-cdc/va-macro@6D44000/va_swr_master";
		swr1 = "/soc/spf_core_platform/lpass-cdc/rx-macro@6AC0000/rx_swr_master";
		swr0 = "/soc/spf_core_platform/lpass-cdc/wsa-macro@6B00000/wsa_swr_master";
		serial0 = "/soc/qcom,qupv3_1_geni_se@ac0000/qcom,qup_uart@a9c000";
		hsuart0 = "/soc/qcom,qupv3_2_geni_se@8c0000/qcom,qup_uart@898000";
		sdhc2 = "/soc/sdhci@8804000";
		ufshc1 = "/soc/ufshc@1d84000";
		i2c4 = "/soc/qcom,qupv3_1_geni_se@ac0000/i2c@a98000";
		i2c6 = "/soc/qcom,qupv3_i2c_geni_se@9c0000/i2c@990000";
		phandle = <0x2e7>;
	};

	sram@17D09400 {
		#address-cells = <0x02>;
		#size-cells = <0x02>;
		compatible = "mmio-sram";
		reg = <0x00 0x17d09400 0x00 0x400>;
		ranges = <0x00 0x00 0x00 0x17d09400 0x00 0x400>;
		phandle = <0x2e8>;

		scmi-shmem@0 {
			compatible = "arm,scmi-shmem";
			reg = <0x00 0x00 0x00 0x400>;
			phandle = <0x2f>;
		};
	};

	firmware {
		phandle = <0x2e9>;

		qcom_scm {
			compatible = "qcom,scm-v1.1\0qcom,scm";
			qcom,dload-mode = <0x03 0x19000>;
			qcom,max-queues = <0x02>;
			interrupts = <0x00 0x3a2 0x01>;
		};

		android {
			compatible = "android,firmware";

			vbmeta {
				compatible = "android,vbmeta";
				parts = "vbmeta,boot,system,vendor,dtbo,recovery";
			};

			fstab {
				compatible = "android,fstab";

				vendor {
					compatible = "android,vendor";
					dev = "/dev/block/platform/soc/1d84000.ufshc/by-name/vendor";
					type = "ext4";
					mnt_flags = "ro,barrier=1,discard";
					fsmgr_flags = "wait,slotselect,avb";
					status = "disabled";
				};
			};
		};

		qcom_smcinvoke {
			compatible = "qcom,smcinvoke";
		};

		qtee_shmbridge {
			compatible = "qcom,tee-shared-memory-bridge";
		};
	};

	cpus {
		#address-cells = <0x02>;
		#size-cells = <0x00>;
		timebase-frequency = <0x124f800>;

		cpu@0 {
			device_type = "cpu";
			compatible = "qcom,kryo";
			reg = <0x00 0x00>;
			enable-method = "psci";
			cpu-idle-states = <0x04>;
			power-domains = <0x05>;
			power-domain-names = "psci";
			cpu-release-addr = <0x00 0xe3940000>;
			qcom,freq-domain = <0x06 0x00>;
			capacity-dmips-mhz = <0x334>;
			dynamic-power-coefficient = <0x64>;
			#cooling-cells = <0x02>;
			next-level-cache = <0x07>;
			phandle = <0x18>;

			l2-cache {
				compatible = "arm,arch-cache";
				cache-level = <0x02>;
				next-level-cache = <0x08>;
				phandle = <0x07>;

				l3-cache {
					compatible = "arm,arch-cache";
					cache-level = <0x03>;
					phandle = <0x08>;
				};
			};
		};

		cpu@100 {
			device_type = "cpu";
			compatible = "qcom,kryo";
			reg = <0x00 0x100>;
			enable-method = "psci";
			cpu-idle-states = <0x04>;
			power-domains = <0x09>;
			power-domain-names = "psci";
			cpu-release-addr = <0x00 0xe3940000>;
			qcom,freq-domain = <0x06 0x00>;
			capacity-dmips-mhz = <0x334>;
			dynamic-power-coefficient = <0x64>;
			#cooling-cells = <0x02>;
			next-level-cache = <0x0a>;
			phandle = <0x19>;

			l2-cache {
				compatible = "arm,arch-cache";
				cache-level = <0x02>;
				next-level-cache = <0x08>;
				phandle = <0x0a>;
			};
		};

		cpu@200 {
			device_type = "cpu";
			compatible = "qcom,kryo";
			reg = <0x00 0x200>;
			enable-method = "psci";
			cpu-idle-states = <0x04>;
			power-domains = <0x0b>;
			power-domain-names = "psci";
			cpu-release-addr = <0x00 0xe3940000>;
			qcom,freq-domain = <0x06 0x00>;
			capacity-dmips-mhz = <0x334>;
			dynamic-power-coefficient = <0x64>;
			#cooling-cells = <0x02>;
			next-level-cache = <0x0a>;
			phandle = <0x1a>;
		};

		cpu@300 {
			device_type = "cpu";
			compatible = "qcom,kryo";
			reg = <0x00 0x300>;
			enable-method = "psci";
			cpu-idle-states = <0x0c>;
			power-domains = <0x0d>;
			power-domain-names = "psci";
			cpu-release-addr = <0x00 0xe3940000>;
			qcom,freq-domain = <0x06 0x01>;
			capacity-dmips-mhz = <0x708>;
			dynamic-power-coefficient = <0x10e>;
			#cooling-cells = <0x02>;
			next-level-cache = <0x0e>;
			phandle = <0x1b>;

			l2-cache {
				compatible = "arm,arch-cache";
				cache-level = <0x02>;
				next-level-cache = <0x08>;
				phandle = <0x0e>;
			};
		};

		cpu@400 {
			device_type = "cpu";
			compatible = "qcom,kryo";
			reg = <0x00 0x400>;
			enable-method = "psci";
			cpu-idle-states = <0x0c>;
			power-domains = <0x0f>;
			power-domain-names = "psci";
			cpu-release-addr = <0x00 0xe3940000>;
			qcom,freq-domain = <0x06 0x01>;
			capacity-dmips-mhz = <0x708>;
			dynamic-power-coefficient = <0x10e>;
			#cooling-cells = <0x02>;
			next-level-cache = <0x10>;
			phandle = <0x1c>;

			l2-cache {
				compatible = "arm,arch-cache";
				cache-level = <0x02>;
				next-level-cache = <0x08>;
				phandle = <0x10>;
			};
		};

		cpu@500 {
			device_type = "cpu";
			compatible = "qcom,kryo";
			reg = <0x00 0x500>;
			enable-method = "psci";
			cpu-idle-states = <0x0c>;
			power-domains = <0x11>;
			power-domain-names = "psci";
			cpu-release-addr = <0x00 0xe3940000>;
			qcom,freq-domain = <0x06 0x01>;
			capacity-dmips-mhz = <0x708>;
			dynamic-power-coefficient = <0x10e>;
			#cooling-cells = <0x02>;
			next-level-cache = <0x12>;
			phandle = <0x1d>;

			l2-cache {
				compatible = "arm,arch-cache";
				cache-level = <0x02>;
				next-level-cache = <0x08>;
				phandle = <0x12>;
			};
		};

		cpu@600 {
			device_type = "cpu";
			compatible = "qcom,kryo";
			reg = <0x00 0x600>;
			enable-method = "psci";
			cpu-idle-states = <0x0c>;
			power-domains = <0x13>;
			power-domain-names = "psci";
			cpu-release-addr = <0x00 0xe3940000>;
			qcom,freq-domain = <0x06 0x01>;
			capacity-dmips-mhz = <0x708>;
			dynamic-power-coefficient = <0x10e>;
			#cooling-cells = <0x02>;
			next-level-cache = <0x14>;
			phandle = <0x1e>;

			l2-cache {
				compatible = "arm,arch-cache";
				cache-level = <0x02>;
				next-level-cache = <0x08>;
				phandle = <0x14>;
			};
		};

		cpu@700 {
			device_type = "cpu";
			compatible = "qcom,kryo";
			reg = <0x00 0x700>;
			enable-method = "psci";
			cpu-idle-states = <0x15>;
			power-domains = <0x16>;
			power-domain-names = "psci";
			cpu-release-addr = <0x00 0xe3940000>;
			qcom,freq-domain = <0x06 0x02>;
			capacity-dmips-mhz = <0x766>;
			dynamic-power-coefficient = <0x24c>;
			#cooling-cells = <0x02>;
			next-level-cache = <0x17>;
			phandle = <0x1f>;

			l2-cache {
				compatible = "arm,arch-cache";
				cache-level = <0x02>;
				next-level-cache = <0x08>;
				phandle = <0x17>;
			};
		};

		cpu-map {
			/* The pinned ADT converter treats every enabled /cpus child as a CPU. */
			status = "disabled";

			cluster0 {

				core0 {
					cpu = <0x18>;
				};

				core1 {
					cpu = <0x19>;
				};

				core2 {
					cpu = <0x1a>;
				};
			};

			cluster1 {

				core0 {
					cpu = <0x1b>;
				};

				core1 {
					cpu = <0x1c>;
				};

				core2 {
					cpu = <0x1d>;
				};

				core3 {
					cpu = <0x1e>;
				};
			};

			cluster2 {

				core0 {
					cpu = <0x1f>;
				};
			};
		};
	};

	idle-states {
		entry-method = "psci";

		silver-c4 {
			compatible = "arm,idle-state";
			idle-state-name = "rail-pc";
			entry-latency-us = <0x226>;
			exit-latency-us = <0x2ee>;
			min-residency-us = <0x1a2c>;
			arm,psci-suspend-param = <0x40000004>;
			local-timer-stop;
			phandle = <0x04>;
		};

		gold-c4 {
			compatible = "arm,idle-state";
			idle-state-name = "rail-pc";
			entry-latency-us = <0x258>;
			exit-latency-us = <0x514>;
			min-residency-us = <0x1fc8>;
			arm,psci-suspend-param = <0x40000004>;
			local-timer-stop;
			phandle = <0x0c>;
		};

		gold-plus-c4 {
			compatible = "arm,idle-state";
			idle-state-name = "rail-pc";
			entry-latencÛ5çkhéì¶»§q«^u6_dup = "/soc/funnel@1080d000";
		funnel_modem_q6_dup_in_modem_etm0 = "/soc/funnel@1080d000/in-ports/port@0/endpoint";
		funnel_modem_q6_dup_out_funnel_modem_q6 = "/soc/funnel@1080d000/out-ports/port/endpoint";
		funnel_modem_q6 = "/soc/funnel@1080c000";
		funnel_modem_q6_in_funnel_modem_q6_dup = "/soc/funnel@1080c000/in-ports/port@1/endpoint";
		funnel_modem_q6_in_modem_diag = "/soc/funnel@1080c000/in-ports/port@2/endpoint";
		funnel_modem_q6_out_funnel_modem = "/soc/funnel@1080c000/out-ports/port/endpoint";
		funnel_modem = "/soc/funnel@10804000";
		funnel_modem_in_modem2_etm0 = "/soc/funnel@10804000/in-ports/port@1/endpoint";
		funnel_modem_in_tpda_modem = "/soc/funnel@10804000/in-ports/port@0/endpoint";
		funnel_modem_in_funnel_modem_q6 = "/soc/funnel@10804000/in-ports/port@3/endpoint";
		funnel_modem_out_funnel_in1 = "/soc/funnel@10804000/out-ports/port/endpoint";
		tpda_apss = "/soc/tpda@13863000";
		tpda_apss_0_in_tpdm_llm_silver = "/soc/tpda@13863000/in-ports/port@0/endpoint";
		tpda_apss_1_in_tpdm_llm_gold = "/soc/tpda@13863000/in-ports/port@1/endpoint";
		tpda_apss_3_in_tpdm_apss0 = "/soc/tpda@13863000/in-ports/port@3/endpoint";
		tpda_apss_2_in_tpdm_apss_llm = "/soc/tpda@13863000/in-ports/port@2/endpoint";
		tpda_apss_4_in_tpdm_apps1 = "/soc/tpda@13863000/in-ports/port@4/endpoint";
		tpda_apss_out_funnel_apss = "/soc/tpda@13863000/out-ports/port/endpoint";
		funnel_apss = "/soc/funnel@13810000";
		funnel_apss_in_funnel_ete = "/soc/funnel@13810000/in-ports/port@0/endpoint";
		funnel_apss_in_tpda_apss = "/soc/funnel@13810000/in-ports/port@2/endpoint";
		funnel_apss_out_funnel_in1 = "/soc/funnel@13810000/out-ports/port/endpoint";
		tpda_dl_center = "/soc/tpda@10c2b000";
		tpda_dl_center_10_in_funnel_dl_west = "/soc/tpda@10c2b000/in-ports/port@a/endpoint";
		tpda_dl_center_13_in_funnel_dl_west = "/soc/tpda@10c2b000/in-ports/port@d/endpoint";
		tpda_dl_center_12_in_funnel_dl_west = "/soc/tpda@10c2b000/in-ports/port@c/endpoint";
		tpda_dl_center_15_in_funnel_turing = "/soc/tpda@10c2b000/in-ports/port@f/endpoint";
		tpda_dl_center_14_in_funnel_dl_west = "/soc/tpda@10c2b000/in-ports/port@e/endpoint";
		tpda_dl_center_17_in_funnel_gfx_dl = "/soc/tpda@10c2b000/in-ports/port@11/endpoint";
		tpda_dl_center_16_in_funnel_turing = "/soc/tpda@10c2b000/in-ports/port@10/endpoint";
		tpda_dl_center_19_in_tpdm_prng = "/soc/tpda@10c2b000/in-ports/port@13/endpoint";
		tpda_dl_center_23_in_tpdm_ipa = "/soc/tpda@10c2b000/in-ports/port@17/endpoint";
		tpda_dl_center_22_in_tpdm_vsense = "/soc/tpda@10c2b000/in-ports/port@16/endpoint";
		tpda_dl_center_26_in_tpdm_dlct = "/soc/tpda@10c2b000/in-ports/port@1a/endpoint";
		tpda_dl_center_20_in_tpdm_qm = "/soc/tpda@10c2b000/in-ports/port@14/endpoint";
		tpda_dl_center_27_in_tpdm_ipcc = "/soc/tpda@10c2b000/in-ports/port@1b/endpoint";
		tpda_dl_center_5_in_funnel_ddr_dl0 = "/soc/tpda@10c2b000/in-ports/port@5/endpoint";
		tpda_dl_center_4_in_funnel_lpass = "/soc/tpda@10c2b000/in-ports/port@4/endpoint";
		tpda_dl_center_7_in_funnel_ddr_dl0 = "/soc/tpda@10c2b000/in-ports/port@7/endpoint";
		tpda_dl_center_6_in_funnel_ddr_dl0 = "/soc/tpda@10c2b000/in-ports/port@6/endpoint";
		tpda_dl_center_9_in_funnel_dl_west = "/soc/tpda@10c2b000/in-ports/port@9/endpoint";
		tpda_dl_center_8_in_funnel_ddr_dl0 = "/soc/tpda@10c2b000/in-ports/port@8/endpoint";
		tpda_dl_center_21_in_tpdm_gcc = "/soc/tpda@10c2b000/in-ports/port@15/endpoint";
		tpda_dl_center_out_funnel_dl_center = "/soc/tpda@10c2b000/out-ports/port/endpoint";
		funnel_dl_center = "/soc/funnel@10c2c000";
		funnel_dl_center_in_tpda_dl_center = "/soc/funnel@10c2c000/in-ports/port@0/endpoint";
		funnel_dl_center_in_funnel_ddr_dl0 = "/soc/funnel@10c2c000/in-ports/port@4/endpoint";
		funnel_dl_center_in_funnel_turing = "/soc/funnel@10c2c000/in-ports/port@6/endpoint";
		funnel_dl_center_in_funnel_gfx_dl = "/soc/funnel@10c2c000/in-ports/port@7/endpoint";
		funnel_dl_center_out_funnel_in1 = "/soc/funnel@10c2c000/out-ports/port/endpoint";
		tpda_qdss = "/soc/tpda@10004000";
		tpda_qdss_1_in_tpdm_spdm = "/soc/tpda@10004000/in-ports/port@1/endpoint";
		tpda_qdss_0_in_tpdm_dcc = "/soc/tpda@10004000/in-ports/port@0/endpoint";
		tpda_qdss_out_funnel_in0 = "/soc/tpda@10004000/out-ports/port/endpoint";
		funnel_in0 = "/soc/funnel@10041000";
		funnel_in0_in_snoc = "/soc/funnel@10041000/in-ports/port@0/endpoint";
		funnel_in0_in_stm = "/soc/funnel@10041000/in-ports/port@7/endpoint";
		funnel_in0_in_tpda_qdss = "/soc/funnel@10041000/in-ports/port@6/endpoint";
		funnel_in0_out_funnel_qdss = "/soc/funnel@10041000/out-ports/port/endpoint";
		funnel_in1 = "/soc/funnel@10042000";
		funnel_in1_in_funnel_dl_south = "/soc/funnel@10042000/in-ports/port@0/endpoint";
		funnel_in1_in_funnel_dl_north = "/soc/funnel@10042000/in-ports/port@1/endpoint";
		funnel_in1_in_funnel_apss = "/soc/funnel@10042000/in-ports/port@4/endpoint";
		funnel_in1_in_funnel_modem = "/soc/funnel@10042000/in-ports/port@5/endpoint";
		funnel_in1_in_funnel_dl_center = "/soc/funnel@10042000/in-ports/port@6/endpoint";
		funnel_in1_out_funnel_qdss = "/soc/funnel@10042000/out-ports/port/endpoint";
		funnel_qdss = "/soc/funnel@10045000";
		funnel_qdss_in_funnel_in1 = "/soc/funnel@10045000/in-ports/port@1/endpoint";
		funnel_qdss_in_funnel_in0 = "/soc/funnel@10045000/in-ports/port@0/endpoint";
		funnel_qdss_out_funnel_aoss = "/soc/funnel@10045000/out-ports/port/endpoint";
		tpda_aoss = "/soc/tpda@10b08000";
		tpda_aoss_0_in_tpdm_swao_prio_0 = "/soc/tpda@10b08000/in-ports/port@0/endpoint";
		tpda_aoss_1_in_tpdm_swao_prio_1 = "/soc/tpda@10b08000/in-ports/port@1/endpoint";
		tpda_aoss_2_in_tpdm_swao_prio_2 = "/soc/tpda@10b08000/in-ports/port@2/endpoint";
		tpda_aoss_3_in_tpdm_swao_prio_3 = "/soc/tpda@10b08000/in-ports/port@3/endpoint";
		tpda_aoss_4_in_tpdm_swao = "/soc/tpda@10b08000/in-ports/port@4/endpoint";
		tpda_aoss_out_funnel_aoss = "/soc/tpda@10b08000/out-ports/port/endpoint";
		funnel_aoss = "/soc/funnel@10b04000";
		funnel_aoss_in_funnel_ddr_lpi = "/soc/funnel@10b04000/in-ports/port@3/endpoint";
		funnel_aoss_in_funnel_lpass_lpi = "/soc/funnel@10b04000/in-ports/port@5/endpoint";
		funnel_aoss_in_funnel_qdss = "/soc/funnel@10b04000/in-ports/port@7/endpoint";
		funnel_aoss_in_tpda_aoss = "/soc/funnel@10b04000/in-ports/port@6/endpoint";
		funnel_aoss_out_tmc_etf = "/soc/funnel@10b04000/out-ports/port/endpoint";
		dummy_eud = "/soc/dummy_sink";
		eud_in_replicator_swao = "/soc/dummy_sink/in-ports/port/endpoint";
		tmc_etf = "/soc/tmc@10b05000";
		tmc_etf_in_funnel_aoss = "/soc/tmc@10b05000/in-ports/port/endpoint";
		tmc_etf_out_replicator_swao = "/soc/tmc@10b05000/out-ports/port/endpoint";
		replicator_swao = "/soc/replicator@10b06000";
		replicator_swao_in_tmc_etf = "/soc/replicator@10b06000/in-ports/port/endpoint";
		replicator_swao_out_replicator_qdss = "/soc/replicator@10b06000/out-ports/port@0/endpoint";
		replicator_swao_out_eud = "/soc/replicator@10b06000/out-ports/port@1/endpoint";
		replicator_qdss = "/soc/replicator@10046000";
		replicator_qdss_in_replicator_swao = "/soc/replicator@10046000/in-ports/port/endpoint";
		replicator_qdss_out_replicator_etr = "/soc/replicator@10046000/out-ports/port@0/endpoint";
		replicator_etr = "/soc/replicator@1004e000";
		replicator_etr_in_replicator_qdss = "/soc/replicator@1004e000/in-ports/port/endpoint";
		replicator_etr_out_tmc_etr = "/soc/replicator@1004e000/out-ports/port@0/endpoint";
		replicator_etr_out_tmc_etr1 = "/soc/replicator@1004e000/out-ports/port@1/endpoint";
		tmc_etr = "/soc/tmc@10048000";
		tmc_etr_in_replicator_etr = "/soc/tmc@10048000/in-ports/port/endpoint";
		tmc_etr1 = "/soc/tmc@1004f000";
		tmc_etr1_in_replicator_etr = "/soc/tmc@1004f000/in-ports/port/endpoint";
		csr = "/soc/csr@10001000";
		swao_csr = "/soc/csr@10b11000";
		qc_cti = "/soc/cti@10010000";
		cti0 = "/soc/cti@10c2a000";
		dlmm_cti0 = "/soc/cti@10c09000";
		ddr_dl_0_cti_0 = "/soc/cti@10d02000";
		ddr_ch02_dl_cti_0 = "/soc/cti@10d21000";
		ddr_ch13_dl_cti_0 = "/soc/cti@10d31000";
		lpass_dl_cti = "/soc/cti@10845000";
		gpu_isdb_cti = "/soc/cti@10961000";
		gpu_cortex_m3 = "/soc/cti@10962000";
		gpu_dl = "/soc/cti@10901000";
		iris_dl_cti = "/soc/cti@10831000";
		mdss_dl_cti = "/soc/cti@10c61000";
		turing_dl_cti_0 = "/soc/cti@10982000";
		turing_q6_cti = "/soc/cti@1098b000";
		swao_cti = "/soc/cti@10b00000";
		ddr_dl2_lpi = "/soc/cti@10b21000";
		ddr_dl_1_cti_0 = "/soc/cti@10d08000";
		cortex_m3 = "/soc/cti@10b13000";
		lpass_lpi_cti1 = "/soc/cti@10b41000";
		lpass_lpi_cti3 = "/soc/cti@10b51000";
		lpass_q6_cti = "/soc/cti@10b4b000";
		lpass_ssc_sdc_cti = "/soc/cti@10b42000";
		apss_cti0 = "/soc/cti@138e0000";
		apss_cti1 = "/soc/cti@138f0000";
		apss_cti2 = "/soc/cti@13900000";
		camera_dl = "/soc/cti@10c15000";
		riscv_cti = "/soc/cti@1382b000";
		riscv_sifive_cti = "/soc/cti@1382e000";
		mss_q6_cti = "/soc/cti@1080b000";
		mss_vq6_cti = "/soc/cti@10813000";
		tmess_cti_0 = "/soc/cti@10cc2000";
		tmess_cti_1 = "/soc/cti@10cc3000";
		tmess_cti_2 = "/soc/cti@10cc4000";
		tmess_cti_3 = "/soc/cti@10cc5000";
		tmess_cti_4 = "/soc/cti@10cc6000";
		tmess_cpu = "/soc/cti@10cd1000";
		modem_tp_cti = "/soc/cti@10802000";
		apss_atb_cti = "/soc/cti@13862000";
		ddrss_shrm2 = "/soc/cti@10d11000";
		cpu0 = "/soc/cti@12010000";
		spss_cti = "/soc/cti@10881000";
		cpu1 = "/soc/cti@12020000";
		cpu2 = "/soc/cti@12030000";
		cpu3 = "/soc/cti@12040000";
		cpu4 = "/soc/cti@12050000";
		cpu5 = "/soc/cti@112060000";
		cpu6 = "/soc/cti@12070000";
		cpu7 = "/soc/cti@12080000";
		ipcb_tgu = "/soc/tgu@10b0e000";
		ete0_out_funnel_ete = "/soc/ete0/out-ports/port/endpoint";
		ete1_out_funnel_ete = "/soc/ete1/out-ports/port/endpoint";
		ete2_out_funnel_ete = "/soc/ete2/out-ports/port/endpoint";
		ete3_out_funnel_ete = "/soc/ete3/out-ports/port/endpoint";
		ete4_out_funnel_ete = "/soc/ete4/out-ports/port/endpoint";
		ete5_out_funnel_ete = "/soc/ete5/out-ports/port/endpoint";
		ete6_out_funnel_ete = "/soc/ete6/out-ports/port/endpoint";
		ete7_out_funnel_ete = "/soc/ete7/out-ports/port/endpoint";
		funnel_ete_out_funnel_apss = "/soc/funnel_ete/out-ports/port/endpoint";
		funnel_ete_in_ete0 = "/soc/funnel_ete/in-ports/port@0/endpoint";
		funnel_ete_in_ete1 = "/soc/funnel_ete/in-ports/port@1/endpoint";
		funnel_ete_in_ete2 = "/soc/funnel_ete/in-ports/port@2/endpoint";
		funnel_ete_in_ete3 = "/soc/funnel_ete/in-ports/port@3/endpoint";
		funnel_ete_in_ete4 = "/soc/funnel_ete/in-ports/port@4/endpoint";
		funnel_ete_in_ete5 = "/soc/funnel_ete/in-ports/port@5/endpoint";
		funnel_ete_in_ete6 = "/soc/funnel_ete/in-ports/port@6/endpoint";
		funnel_ete_in_ete7 = "/soc/funnel_ete/in-ports/port@7/endpoint";
		dcc = "/soc/dcc_v2@100ff000";
		gpi_dma1 = "/soc/qcom,gpi-dma@a00000";
		qupv3_1 = "/soc/qcom,qupv3_1_geni_se@ac0000";
		qupv3_se7_2uart = "/soc/qcom,qupv3_1_geni_se@ac0000/qcom,qup_uart@a9c000";
		qupv3_se0_i2c = "/soc/qcom,qupv3_1_geni_se@ac0000/i2c@a80000";
		i3c1 = "/soc/qcom,qupv3_1_geni_se@ac0000/i3c-master@a80000";
		qupv3_se0_spi = "/soc/qcom,qupv3_1_geni_se@ac0000/spi@a80000";
		qupv3_se1_i2c = "/soc/qcom,qupv3_1_geni_se@ac0000/i2c@a84000";
		i3c2 = "/soc/qcom,qupv3_1_geni_se@ac0000/i3c-master@a84000";
		qupv3_se1_spi = "/soc/qcom,qupv3_1_geni_se@ac0000/spi@a84000";
		qupv3_se2_i2c = "/soc/qcom,qupv3_1_geni_se@ac0000/i2c@a88000";
		qupv3_se2_spi = "/soc/qcom,qupv3_1_geni_se@ac0000/spi@a88000";
		qupv3_se3_i2c = "/soc/qcom,qupv3_1_geni_se@ac0000/i2c@a8c000";
		qupv3_se3_spi = "/soc/qcom,qupv3_1_geni_se@ac0000/spi@a8c000";
		qupv3_se4_i2c = "/soc/qcom,qupv3_1_geni_se@ac0000/i2c@a90000";
		qupv3_se4_spi = "/soc/qcom,qupv3_1_geni_se@ac0000/spi@a90000";
		qupv3_se4_4uart = "/soc/qcom,qupv3_1_geni_se@ac0000/qcom,qup_uart@a90000";
		qupv3_se5_i2c = "/soc/qcom,qupv3_1_geni_se@ac0000/i2c@a94000";
		qupv3_se5_spi = "/soc/qcom,qupv3_1_geni_se@ac0000/spi@a94000";
		qupv3_se6_i2c = "/soc/qcom,qupv3_1_geni_se@ac0000/i2c@a98000";
		qupv3_se6_spi = "/soc/qcom,qupv3_1_geni_se@ac0000/spi@a98000";
		gpi_dma2 = "/soc/qcom,gpi-dma@800000";
		qupv3_2 = "/soc/qcom,qupv3_2_geni_se@8c0000";
		qupv3_se8_i2c = "/soc/qcom,qupv3_2_geni_se@8c0000/i2c@880000";
		i3c3 = "/soc/qcom,qupv3_2_geni_se@8c0000/i3c-master@880000";
		qupv3_se8_spi = "/soc/qcom,qupv3_2_geni_se@8c0000/spi@880000";
		qupv3_se9_i2c = "/soc/qcom,qupv3_2_geni_se@8c0000/i2c@884000";
		i3c0 = "/soc/qcom,qupv3_2_geni_se@8c0000/i3c-master@884000";
		qupv3_se9_spi = "/soc/qcom,qupv3_2_geni_se@8c0000/spi@884000";
		qupv3_se10_i2c = "/soc/qcom,qupv3_2_geni_se@8c0000/i2c@888000";
		qupv3_se10_spi = "/soc/qcom,qupv3_2_geni_se@8c0000/spi@888000";
		qupv3_se11_i2c = "/soc/qcom,qupv3_2_geni_se@8c0000/i2c@88c000";
		qupv3_se11_spi = "/soc/qcom,qupv3_2_geni_se@8c0000/spi@88c000";
		qupv3_se12_i2c = "/soc/qcom,qupv3_2_geni_se@8c0000/i2c@890000";
		qupv3_se12_spi = "/soc/qcom,qupv3_2_geni_se@8c0000/spi@890000";
		qupv3_se13_i2c = "/soc/qcom,qupv3_2_geni_se@8c0000/i2c@894000";
		qupv3_se13_spi = "/soc/qcom,qupv3_2_geni_se@8c0000/spi@894000";
		qupv3_se14_4uart = "/soc/qcom,qupv3_2_geni_se@8c0000/qcom,qup_uart@898000";
		qupv3_se15_i2c = "/soc/qcom,qupv3_2_geni_se@8c0000/i2c@89c000";
		qupv3_se15_spi = "/soc/qcom,qupv3_2_geni_se@8c0000/spi@89c000";
		qupv3_se15_4uart = "/soc/qcom,qupv3_2_geni_se@8c0000/qcom,qup_uart@89c000";
		qupv3_0_i2c_hub = "/soc/qcom,qupv3_i2c_geni_se@9c0000";
		qupv3_hub_i2c0 = "/soc/qcom,qupv3_i2c_geni_se@9c0000/i2c@980000";
		qupv3_hub_i2c1 = "/soc/qcom,qupv3_i2c_geni_se@9c0000/i2c@984000";
		qupv3_hub_i2c2 = "/soc/qcom,qupv3_i2c_geni_se@9c0000/i2c@988000";
		fsa4480 = "/soc/qcom,qupv3_i2c_geni_se@9c0000/i2c@988000/fsa4480@42";
		qupv3_hub_i2c3 = "/soc/qcom,qupv3_i2c_geni_se@9c0000/i2c@98c000";
		qupv3_hub_i2c4 = "/soc/qcom,qupv3_i2c_geni_se@9c0000/i2c@990000";
		qupv3_hub_i2c5 = "/soc/qcom,qupv3_i2c_geni_se@9c0000/i2c@994000";
		qupv3_hub_i2c6 = "/soc/qcom,qupv3_i2c_geni_se@9c0000/i2c@998000";
		qupv3_hub_i2c7 = "/soc/qcom,qupv3_i2c_geni_se@9c0000/i2c@99c000";
		qupv3_hub_i2c8 = "/soc/qcom,qupv3_i2c_geni_se@9c0000/i2c@9a0000";
		qupv3_hub_i2c9 = "/soc/qcom,qupv3_i2c_geni_se@9c0000/i2c@9a4000";
		usb0 = "/soc/ssusb@a600000";
		eusb2_phy0 = "/soc/hsphy@88e3000";
		usb_qmp_dp_phy = "/soc/ssphy@88e8000";
		msm_cvp = "/soc/qcom,cvp@ab00000";
		pcie0 = "/soc/qcom,pcie@1c00000";
		pcie0_rp = "/soc/qcom,pcie@1c00000/pcie0_rp";
		pcie0_msi = "/soc/qcom,pcie0_msi@0x17110040";
		pcie1 = "/soc/qcom,pcie@1c08000";
		pcie1_rp = "/soc/qcom,pcie@1c08000/pcie1_rp";
		tsens0 = "/soc/tsens0@c271000";
		tsens1 = "/soc/tsens1@c272000";
		tsens2 = "/soc/tsens2@c273000";
		cpu1_pause = "/soc/qcom,cpu-pause/cpu1-pause";
		cpu2_pause = "/soc/qcom,cpu-pause/cpu2-pause";
		cpu3_pause = "/soc/qcom,cpu-pause/cpu3-pause";
		cpu4_pause = "/soc/qcom,cpu-pause/cpu4-pause";
		cpu5_pause = "/soc/qcom,cpu-pause/cpu5-pause";
		cpu6_pause = "/soc/qcom,cpu-pause/cpu6-pause";
		cpu7_pause = "/soc/qcom,cpu-pause/cpu7-pause";
		APC1_pause = "/soc/qcom,cpu-pause/apc1-pause";
		cpu_3_4_5_pause = "/soc/qcom,cpu-pause/cpu-3-4-5-pause";
		cpu_6_7_pause = "/soc/qcom,cpu-pause/cpu-6-7-pause";
		cpu1_hotplug = "/soc/qcom,cpu-hotplug/cpu1-hotplug";
		cpu2_hotplug = "/soc/qcom,cpu-hotplug/cpu2-hotplug";
		cpu3_hotplug = "/soc/qcom,cpu-hotplug/cpu3-hotplug";
		cpu4_hotplug = "/soc/qcom,cpu-hotplug/cpu4-hotplug";
		cpu5_hotplug = "/soc/qcom,cpu-hotplug/cpu5-hotplug";
		cpu6_hotplug = "/soc/qcom,cpu-hotplug/cpu6-hotplug";
		cpu7_hotplug = "/soc/qcom,cpu-hotplug/cpu7-hotplug";
		apc1_cluster = "/soc/qcom,cpu-voltage-cdev/qcom,apc1-cluster";
		ddr_cdev = "/soc/qcom,ddr-cdev";
		qmi_tmd = "/soc/qmi-tmd-devices";
		cdsp_sw = "/soc/qmi-tmd-devices/cdsp/cdsp";
		cdsp_hw = "/soc/qmi-tmd-devices/cdsp/cdsp_hw";
		modem_lte_dsc = "/soc/qmi-tmd-devices/modem/modem_lte_dsc";
		modem_nr_dsc = "/soc/qmi-tmd-devices/modem/modem_nr_dsc";
		modem_nr_scg_dsc = "/soc/qmi-tmd-devices/modem/modem_nr_scg_dsc";
		sdr0_lte_dsc = "/soc/qmi-tmd-devices/modem/sdr0_lte_dsc";
		sdr1_lte_dsc = "/soc/qmi-tmd-devices/modem/sdr1_lte_dsc";
		sdr0_nr_dsc = "/soc/qmi-tmd-devices/modem/sdr0_nr_dsc";
		sdr1_nr_dsc = "/soc/qmi-tmd-devices/modem/sdr1_nr_dsc";
		sdr0_nr_scg_dsc = "/soc/qmi-tmd-devices/modem/sdr0_nr_scg_dsc";
		sdr1_nr_scg_dsc = "/soc/qmi-tmd-devices/modem/sdr1_nr_scg_dsc";
		pa_lte_sdr0_dsc = "/soc/qmi-tmd-devices/modem/pa_lte_sdr0_dsc";
		pa_lte_sdr1_dsc = "/soc/qmi-tmd-devices/modem/pa_lte_sdr1_dsc";
		pa_nr_sdr0_dsc = "/soc/qmi-tmd-devices/modem/pa_nr_sdr0_dsc";
		pa_nr_sdr1_dsc = "/soc/qmi-tmd-devices/modem/pa_nr_sdr1_dsc";
		pa_nr_sdr0_scg_dsc = "/soc/qmi-tmd-devices/modem/pa_nr_sdr0_scg_dsc";
		pa_nr_sdr1_scg_dsc = "/soc/qmi-tmd-devices/modem/pa_nr_sdr1_scg_dsc";
		mmw0_dsc = "/soc/qmi-tmd-devices/modem/mmw0_dsc";
		mmw1_dsc = "/soc/qmi-tmd-devices/modem/mmw1_dsc";
		mmw2_dsc = "/soc/qmi-tmd-devices/modem/mmw2_dsc";
		mmw3_dsc = "/soc/qmi-tmd-devices/modem/mmw3_dsc";
		mmw_ific_dsc = "/soc/qmi-tmd-devices/modem/mmw_ific_dsc";
		qmi_wlan = "/soc/qmi-tmd-devices/modem/wlan";
		modem_bw_backoff = "/soc/qmi-tmd-devices/modem/modem_bw_backoff";
		modem_vdd = "/soc/qmi-tmd-devices/modem/modem_vdd";
		display_fps = "/soc/qcom,userspace-cdev/display-fps";
		limits_stat = "/soc/limits-stat";
		qmi_sensor = "/soc/qmi-ts-sensors";
	};

	hypervisor {
		#address-cells = <0x02>;
		#size-cells = <0x00>;
		compatible = "qcom,gunyah-hypervisor-1.0\0qcom,gunyah-hypervisor\0simple-bus";

		qcom,gunyah-vm {
			compatible = "qcom,gunyah-vm-id-1.0\0qcom,gunyah-vm-id";
			qcom,vmid = <0x03>;
			qcom,vendor = "Qualcomm";
		};

		qcom,gh-watchdog {
			compatible = "qcom,gh-watchdog";
			interrupts = <0x00 0x00 0x01>;
		};

		qcom,resource-manager-rpc@4d8f0a856c4e857d {
			compatible = "qcom,resource-manager-1-0\0qcom,resource-manager\0qcom,gunyah-message-queue\0qcom,gunyah-capability";
			reg = <0x4d8f0a85 0x6c4e857d 0x4d8f0a85 0x6c4e37a2>;
			interrupts = <0x00 0x3a0 0x01 0x00 0x3a1 0x01>;
			qcom,free-irq-start = <0x3c0>;
			qcom,is-full-duplex;
			qcom,tx-message-size = <0xf0>;
			qcom,rx-message-size = <0xf0>;
			qcom,tx-queue-depth = <0x08>;
			qcom,rx-queue-depth = <0x08>;
		};
	};
};
